# Autodesk Inventor part: 1756900_Teil2
## iProperties
Created: 2008-11
Part Number: 1756900_Teil2
Document SubType Name: Modeling
Designer: jjug
Author: jjug
## Feature names
1. Base1
